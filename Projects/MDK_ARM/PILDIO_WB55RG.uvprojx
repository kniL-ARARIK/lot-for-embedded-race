# Keil uVision project PILDIO_WB55RG.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x000040000) IROM(0x08000000,0x001000000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: PILDIO_WB55RG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\SYSTEM;..\..\Drivers\CMSIS\Inc;..\..\Drivers\STM32WBxx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Start
    ./: startup_stm32wb55xx_cm4.s
  group User
    ../../User/: main.c stm32wbxx_it.c system_stm32wbxx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/: sys.c
  group STM32WBxx_HAL_Driver
    ../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_gpio.c stm32wbxx_hal_uart.c stm32wbxx_hal_usart.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_ll_rcc.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c
